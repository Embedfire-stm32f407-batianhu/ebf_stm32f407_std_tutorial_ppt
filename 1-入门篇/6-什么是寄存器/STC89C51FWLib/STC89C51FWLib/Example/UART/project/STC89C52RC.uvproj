# Keil uVision project STC89C52RC.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: STC89C52RC +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: ..\Library\inc;..\Library\src;..\Library\StartUp
  group StartUp
    ../Library/StartUp/: STARTUP.A51
  group FWLib
    ../Library/src/: stc89c51_uart.c
  group User
    ../User/: main.c
    ../Library/src/: stc89c51_it.c
    ../Library/inc/: stc89c51_conf.h
